# Keil uVision project VehicleDetector.uvprojx, settings and files
target VehicleDetector (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VehicleDetector
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;                              ../Drivers/STM32L1xx_HAL_Driver/Inc;                              ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;                              ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;                              ../Drivers/CMSIS/Include;                              ..\Hardware\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_adc.c stm32l1xx_ll_exti.c stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_dma.c stm32l1xx_ll_usart.c stm32l1xx_ll_gpio.c stm32l1xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Hardware
    ../Hardware/Src/: accelerate.c noise.c public.c oled.c pressure.c ble.c process.c analog.c ultrasonicwave.c encode.c
  group Application/User
    ../Src/: main.c stm32l1xx_hal_msp.c gpio.c adc.c tim.c stm32l1xx_it.c dma.c usart.c
software components: CMSIS:CORE 4.1.0
